Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-10T08:18:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 10 08:18:46 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\93ec34d6-87e7-4e0f-a857-9f0d61f4248b\54bf20cd-3c69-4219-b687-027f904c8556\ifc * Database version: 5507 * Database creation date: Tue Jan 10 08:18:45 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 10 08:18:45 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 10 08:18:45 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11581130_RU_CM6560_GRPF:29656003_RU_11581130_CM6560_GRPF, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 29656003_RU_11581130_CM6560_GRPF
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 29656003_RU_11581130_CM6560_GRPF
Type - Pset_ProvisionForVoid - Width: 251 mm; Height: 359 mm; Depth: 427 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Glass, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - sets with these values: 2
